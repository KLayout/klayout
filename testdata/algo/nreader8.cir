.include "nreader8a.cir"
.include ../algo/nreader8b.cir
.inc nreader8c.cir
